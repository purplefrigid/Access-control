# Keil uVision project HFRFID.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Uart_Interrupt +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib;.\Lib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ./Lib/: stm32f10x_it.c system_stm32f10x.c core_cm3.c
    ./Lib/src/: stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_tim.c
  group Start
    ./Start/: startup_stm32f10x_hd.s
  group User
    ./User/: main.c Uart.c
software components: CMSIS:CORE 5.0.1
